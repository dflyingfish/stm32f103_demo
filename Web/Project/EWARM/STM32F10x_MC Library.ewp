# IAR project STM32F10x_MC Library.ewp, settings and files
configuration STM32F10x_SINGLE_DRIVE (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; MC_LIBRARY_SINGLE
  ICCARM.CCIncludePath2: ..\; ..\..\MCLibrary\; ..\..\MCLibrary\inc\; ..\..\MCLibrary\interface\; ..\..\MCLibrary\interface\common\; ..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MC architecture.srec
  ILINK.IlinkOutputFile: MC architecture.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F10x_DUAL_DRIVE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; MC_LIBRARY_DUAL
  group (top)
    ../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group MC Library
    ../../MCLibrary/: MCLibraryConf.h stm32f10x_MisraCompliance.h
  group MC Library/interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h GAP_GateDriverCtrlClass.h GateDriverCtrlClass.h HALL_SpeednPosFdbkClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group MC Library/interface/common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h RampExtMngrClass.h RampMngrClass.h
  group MC Library/obj/Dual Drive
    ../../MCLibrary/obj/Dual Drive/: FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o MTPACtrlClass.o RevupCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/obj/Single Drive
    ../../MCLibrary/obj/Single Drive/: FeedForwardCtrlClass.o FluxWeakeningCtrlClass.o MTPACtrlClass.o RevupCtrlClass.o STO_CORDIC_SpeednPosFdbkClass.o STO_SpeednPosFdbkClass.o
  group MC Library/private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h DigitalOutputPrivate.h EncAlignCtrlPrivate.h ENCODER_SpeednPosFdbkPrivate.h GAP_GateDriverCtrlPrivate.h GateDriverCtrlPrivate.h HALL_SpeednPosFdbkPrivate.h ICS_HD2_PWMnCurrFdbkPrivate.h ICS_LM1_PWMnCurrFdbkPrivate.h InrushCurrentLimiterPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h NTC_TemperatureSensorPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h R1_HD2_PWMnCurrFdbkPrivate.h R1_LM1_PWMnCurrFdbkPrivate.h R1_VL1_PWMnCurrFdbkPrivate.h R3_HD2_PWMnCurrFdbkPrivate.h R3_LM1_PWMnCurrFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h Rdivider_BusVoltageSensorPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h
  group MC Library/src
    ../../MCLibrary/src/: BusVoltageSensorClass.c CircleLimitationClass.c DigitalOutputClass.c EncAlignCtrlClass.c ENCODER_SpeednPosFdbkClass.c GAP_F1xx_GateDriverCtrlClass.c GAP_GateDriverCtrlClass.c GateDriverCtrlClass.c HALL_SpeednPosFdbkClass.c ICS_HD2_PWMnCurrFdbkClass.c ICS_LM1_PWMnCurrFdbkClass.c InrushCurrentLimiterClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c NTC_TemperatureSensorClass.c OpenLoopClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c R1_HD2_PWMnCurrFdbkClass.c R1_LM1_PWMnCurrFdbkClass.c R1_VL1_PWMnCurrFdbkClass.c R3_HD2_PWMnCurrFdbkClass.c R3_LM1_PWMnCurrFdbkClass.c RampExtMngrClass.c RampMngrClass.c Rdivider_BusVoltageSensorClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c
